# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 oTime=1 uC99=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\C++LIB\OnChip\GPIO;..\C++LIB\ToolBox\Buffer;..\C++LIB\System;..\C++LIB\OnChip\IIC;..\C++LIB\OffChip;..\C++LIB\System\TaskManager;..\C++LIB\System\Interrupt;..\C++LIB\OnChip\SerialPort
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.cpp system_stm32f10x.c String.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group C++LIB
    ../C++LIB/OnChip/GPIO/: GPIO.cpp
    ../C++LIB/OnChip/SerialPort/: USART.cpp
    ../C++LIB/System/TaskManager/: TaskManager.cpp
    ../C++LIB/System/Interrupt/: Interrupt.cpp
    ../C++LIB/OnChip/IIC/: I2C.cpp IIC.cpp
    ../C++LIB/OnChip/Timer/: Timer.cpp
    ../C++LIB/OnChip/SPI/: SPI.cpp
    ../C++LIB/OnChip/ADC/: ADC.cpp
    ../C++LIB/OnChip/PWM/: PWM.cpp
    ../C++LIB/System/: Configuration.h
    ../C++LIB/OnChip/InputCapture/: InputCapture_EXIT.cpp InputCapture_TIM.cpp
